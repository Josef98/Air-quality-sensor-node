# Keil uVision project I2C.uvproj, settings and files
target I2C (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NANO103ZD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group Source files
    ../: main.c
    ./nano_support/: Nano_support.c
    ./bst_exp/: bsec_integration.c
    ./bst_driver/: bme680.c bma2x2.c bma2x2_support.c
  group Library files
    ../../../../Library/StdDriver/src/: i2c.c sys.c uart.c clk.c retarget.c timer.c fmc.c
    ./bst_algo/: libalgobsec.lib
